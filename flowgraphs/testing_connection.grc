options:
  parameters:
    author: degan
    generate_options: qt_gui
    id: testing_connection
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: crc_poly
  id: variable
  parameters:
    value: '450'
  states: {}
- name: frame_len
  id: variable
  parameters:
    value: '450'
  states: {}
- name: host_ip
  id: variable
  parameters:
    value: '''127.0.0.1'''
  states: {}
- name: host_ip_0
  id: variable
  parameters:
    value: '''127.0.0.1'''
  states: {}
- name: mod_dev
  id: variable
  parameters:
    value: '450'
  states: {}
- name: payload_len
  id: variable
  parameters:
    value: '450'
  states: {}
- name: preamble_byte
  id: variable
  parameters:
    value: '450'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: sync_word
  id: variable
  parameters:
    value: '0xD391C1E3'
  states: {}
- name: tcp_port
  id: variable
  parameters:
    value: '''52001'''
  states: {}
- name: Output
  id: blocks_file_sink
  parameters:
    file: C:\Users\degan\OneDrive\Documents\Work\Projects\UVSD\Information\raspiENV\scripts\output.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: |
      pmt.cons(pmt.make_dict(), pmt.make_u8vector(4, ord('x')))
    period: '1000'
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: host_ip
    mtu: '10000'
    port: tcp_port
    type: TCP_SERVER
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}

connections:
- [blocks_message_strobe_0, strobe, network_socket_pdu_0, pdus]
- [network_socket_pdu_0, pdus, blocks_message_debug_0, print]
- [network_socket_pdu_0, pdus, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', Output, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
