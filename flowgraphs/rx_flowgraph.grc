options:
  parameters:
    generate_options: qt_gui
    id: rx_flowgraph
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: frequency
  id: variable_qtgui_chooser
  parameters:
    label0: 'Frequency: 0'
    label1: 'Frequency: 1000'
    label2: 'Frequency: -2000'
    num_opts: '3'
    option0: '0'
    option1: '1000'
    option2: '-2000'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '101010'
    type: float
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52001'
    type: TCP_SERVER
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: satellites_crc_check_0
  id: satellites_crc_check
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: satellites_fixedlen_to_pdu_0
  id: satellites_fixedlen_to_pdu
  parameters:
    syncword_tag: syncword
    type: complex
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_tagged_stream_align_0, '0', satellites_fixedlen_to_pdu_0, '0']
- [blocks_throttle2_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_tagged_stream_align_0, '0']
- [satellites_crc_check_0, fail, network_socket_pdu_0, pdus]
- [satellites_crc_check_0, ok, network_socket_pdu_0, pdus]
- [satellites_fixedlen_to_pdu_0, pdus, satellites_crc_check_0, in]
- [soapy_limesdr_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
