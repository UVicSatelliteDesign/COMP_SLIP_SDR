options:
  parameters:
    generate_options: qt_gui
    id: rx_flowgraph
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Bandwith
  id: variable
  parameters:
    value: '1.2'
  states: {}
- name: RF_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: crc_poly
  id: variable
  parameters:
    value: '450'
  states: {}
- name: f_dev
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: frame_len
  id: variable
  parameters:
    value: '450'
  states: {}
- name: freq_correction
  id: variable
  parameters:
    value: '0'
  states: {}
- name: frequency
  id: variable_qtgui_chooser
  parameters:
    label0: 'Frequency: 0'
    label1: 'Frequency: 1000'
    label2: 'Frequency: -2000'
    num_opts: '3'
    option0: '0'
    option1: '1000'
    option2: '-2000'
    type: int
    value: '0'
  states: {}
- name: host_ip
  id: variable
  parameters:
    value: '''127.0.0.1'''
  states: {}
- name: host_ip_0
  id: variable
  parameters:
    value: '''127.0.0.1'''
  states: {}
- name: mod_dev
  id: variable
  parameters:
    value: '450'
  states: {}
- name: payload_len
  id: variable
  parameters:
    value: '450'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '10101010'
  states: {}
- name: preamble_byte
  id: variable
  parameters:
    value: '450'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4.8'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: "\t2*3.141592653589793*f_dev/samp_rate"
  states: {}
- name: sync_word
  id: variable
  parameters:
    value: '1'
  states: {}
- name: sync_word_0
  id: variable
  parameters:
    value: '0xD391C1E3'
  states: {}
- name: tcp_port
  id: variable
  parameters:
    value: '''52001'''
  states: {}
- name: Output
  id: blocks_file_sink
  parameters:
    file: C:\Users\degan\OneDrive\Documents\Work\Projects\UVSD\Information\raspiENV\scripts\output.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: |
      pmt.cons(pmt.make_dict(), pmt.make_u8vector(4, ord('x')))
    period: '1000'
  states: {}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024 '
    long_form: 'False'
    type: cc
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '101010'
    type: float
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '4'
    sensitivity: sensitivity
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52001'
    type: TCP_SERVER
  states: {}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    host: host_ip
    mtu: '10000'
    port: tcp_port
    type: TCP_SERVER
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: satellites_crc_check_0
  id: satellites_crc_check
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: satellites_fixedlen_to_pdu_0
  id: satellites_fixedlen_to_pdu
  parameters:
    syncword_tag: syncword
    type: complex
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    bandwidth: Bandwith
    center_freq: center_freq
    dev_args: driver=lime
    gain: RF_gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_message_strobe_0, strobe, network_socket_pdu_0_0, pdus]
- [blocks_tagged_stream_align_0, '0', satellites_fixedlen_to_pdu_0, '0']
- [blocks_throttle2_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [dc_blocker_xx_0, '0', digital_gfsk_demod_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_tagged_stream_align_0, '0']
- [digital_gfsk_demod_0, '0', blocks_throttle2_0, '0']
- [network_socket_pdu_0, pdus, blocks_message_debug_0, print_pdu]
- [network_socket_pdu_0, pdus, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', Output, '0']
- [satellites_crc_check_0, fail, network_socket_pdu_0, pdus]
- [satellites_crc_check_0, ok, network_socket_pdu_0, pdus]
- [satellites_fixedlen_to_pdu_0, pdus, satellites_crc_check_0, in]
- [soapy_limesdr_source_0, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
