options:
  parameters:
    generate_options: qt_gui
    id: rx_flowgraph
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Bandwith
  id: variable
  parameters:
    value: 30.72e6
  states: {}
- name: K
  id: variable
  parameters:
    value: '8'
  states: {}
- name: RF_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: crc_poly
  id: variable
  parameters:
    value: '0x8005'
  states: {}
- name: frame_len
  id: variable
  parameters:
    value: '450'
  states: {}
- name: host_ip
  id: variable
  parameters:
    value: '''127.0.0.1'''
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '8'
  states: {}
- name: payload_len
  id: variable
  parameters:
    value: '128'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '0b10101010'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 30.72e6
  states: {}
- name: sync_word
  id: variable
  parameters:
    value: '1'
  states: {}
- name: tcp_port
  id: variable
  parameters:
    value: '''52001'''
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '0'
  states: {}
- name: variable_0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: Output
  id: blocks_file_sink
  parameters:
    file: rx_output.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/liamshatzel/code/UVSD/COMP_SLIP_SDR/flowgraphs/tx_baseband.cfile
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters:
    log_level: err
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: |
      pmt.cons(pmt.make_dict(), pmt.make_u8vector(4, ord('x')))
    period: '1000'
  states: {state: disabled}
- name: blocks_repack_bits_bb_2
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: packet_len
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    tagname: packet_len
    threshold: threshold
    type: byte
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    log: 'True'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
    sensitivity: '1'
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '1500'
    port: '52001'
    type: TCP_SERVER
  states: {}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    host: host_ip
    mtu: '10000'
    port: tcp_port
    type: TCP_SERVER
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: satellites_crc_check_0
  id: satellites_crc_check
  parameters:
    num_bits: '16'
    poly: crc_poly
  states: {}

connections:
- [blocks_file_source_0, '0', digital_gfsk_demod_0, '0']
- [blocks_message_strobe_0, strobe, network_socket_pdu_0_0, pdus]
- [blocks_repack_bits_bb_2, '0', blocks_tagged_stream_align_0, '0']
- [blocks_tagged_stream_align_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_throttle2_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_2, '0']
- [digital_gfsk_demod_0, '0', blocks_throttle2_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', Output, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, satellites_crc_check_0, in]
- [satellites_crc_check_0, fail, blocks_message_debug_0_0, log]
- [satellites_crc_check_0, ok, network_socket_pdu_0, pdus]
- [satellites_crc_check_0, ok, pdu_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
