options:
  parameters:
    generate_options: qt_gui
    id: rx_flowgraph
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: Bandwith
  id: variable
  parameters:
    value: 30.72e6
  states: {}
- name: K
  id: variable
  parameters:
    value: '8'
  states: {}
- name: RF_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: crc_poly
  id: variable
  parameters:
    value: '0x8005'
  states: {}
- name: frame_len
  id: variable
  parameters:
    value: '450'
  states: {}
- name: host_ip
  id: variable
  parameters:
    value: '''127.0.0.1'''
  states: {}
- name: payload_len
  id: variable
  parameters:
    value: '128'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '0b10101010'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e3
  states: {}
- name: sync_word
  id: variable
  parameters:
    value: '1'
  states: {}
- name: tcp_port
  id: variable
  parameters:
    value: '''52001'''
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '0'
  states: {}
- name: variable_0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: Output_0
  id: blocks_file_sink
  parameters:
    file: rx_output.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: Output_0_0
  id: blocks_file_sink
  parameters:
    file: rx_dbg2.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: Output_0_0_1
  id: blocks_file_sink
  parameters:
    file: rx_dbg1.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: tx_baseband.cfile
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: tx_data.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_file_source_1_0
  id: blocks_file_source
  parameters:
    file: tx_data.txt
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters:
    log_level: err
  states: {}
- name: blocks_message_debug_0_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_repack_bits_bb_2
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: packet_len
  states: {}
- name: blocks_repack_bits_bb_2_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: ''
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    name: AtInput
    type: byte
  states: {}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    comment: values should be 1/8 that of AtInput
    name: AtRepack
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: |-
      ===   WARNING   ===
      This flowgraph works EXCEPT for the GFSK Mod/Demod blocks:
      unpacking tx_data.txt is entirely valid but feeding it through 
      mod/demod truncates exactly the last byte of the stream.
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    tagname: packet_len
    threshold: threshold
    type: byte
  states: {}
- name: digital_crc_check_0_0
  id: digital_crc_check
  parameters:
    discard_crc: 'True'
    num_bits: '16'
    poly: crc_poly
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
    sensitivity: '1'
  states: {state: disabled}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {state: disabled}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '1500'
    port: '52001'
    type: TCP_SERVER
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Bytestream
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Bytestream
  states: {}

connections:
- [blocks_file_source_0, '0', digital_gfsk_demod_0, '0']
- [blocks_file_source_1, '0', blocks_repack_bits_bb_2_0, '0']
- [blocks_file_source_1_0, '0', digital_gfsk_mod_0, '0']
- [blocks_repack_bits_bb_2, '0', Output_0_0, '0']
- [blocks_repack_bits_bb_2, '0', blocks_tag_debug_0_0, '0']
- [blocks_repack_bits_bb_2, '0', virtual_sink_0, '0']
- [blocks_repack_bits_bb_2_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', Output_0_0_1, '0']
- [blocks_throttle2_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_2, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_tag_debug_0, '0']
- [digital_crc_check_0_0, fail, blocks_message_debug_0_0, print]
- [digital_crc_check_0_0, ok, blocks_message_debug_0, print]
- [digital_crc_check_0_0, ok, network_socket_pdu_0_0, pdus]
- [digital_crc_check_0_0, ok, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_gfsk_demod_0, '0', blocks_throttle2_0, '0']
- [digital_gfsk_mod_0, '0', digital_gfsk_demod_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', Output_0, '0']
- [pdu_tagged_stream_to_pdu_0_0, pdus, blocks_message_debug_0_1, print]
- [pdu_tagged_stream_to_pdu_0_0, pdus, digital_crc_check_0_0, in]
- [virtual_source_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
