options:
  parameters:
    generate_options: qt_gui
    id: tx_flowgraph
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: crc_poly
  id: variable
  parameters:
    value: '0x8005'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: host_ip
  id: variable
  parameters:
    value: '''127.0.0.1'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: soapy_freq
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tcp_port
  id: variable
  parameters:
    value: '''52001'''
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL,pmt.init_u8vector(9,(71,78,85,32,82,97,100,105,111)))
    period: '500'
  states: {state: disabled}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.make_dict(), pmt.make_u8vector(4, ord('x')))
    period: '1000'
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: tx_baseband.wav
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: samp_rate
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    num_bits: '16'
    poly: crc_poly
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    host: host_ip
    mtu: '10000'
    port: tcp_port
    type: TCP_SERVER
  states: {}
- name: outputFromTX
  id: blocks_file_sink
  parameters:
    file: tx_baseband.cfile
    type: complex
  states: {}
- name: outputFromTX_0
  id: blocks_file_sink
  parameters:
    file: tx_data.txt
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: soapy_limesdr_sink_0
  id: soapy_limesdr_sink
  parameters:
    center_freq: soapy_freq
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0, '1']
- [blocks_message_strobe_0, strobe, digital_crc_append_0, in]
- [blocks_message_strobe_0_0, strobe, digital_crc_append_0, in]
- [blocks_tagged_stream_mux_0, '0', digital_gfsk_mod_0, '0']
- [blocks_tagged_stream_mux_0, '0', outputFromTX_0, '0']
- [digital_crc_append_0, out, digital_protocol_formatter_async_0, in]
- [digital_gfsk_mod_0, '0', blocks_complex_to_float_0, '0']
- [digital_gfsk_mod_0, '0', outputFromTX, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0_0, pdus]
- [network_socket_pdu_0_0, pdus, digital_crc_append_0, in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
