options:
  parameters:
    generate_options: qt_gui
    id: tx_flowgraph
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52001'
    type: TCP_SERVER
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [network_socket_pdu_0, pdus, soapy_limesdr_source_0, cmd]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
