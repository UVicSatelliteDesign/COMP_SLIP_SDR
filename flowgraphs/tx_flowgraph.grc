options:
  parameters:
    generate_options: qt_gui
    id: tx_flowgraph
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: host_ip
  id: variable
  parameters:
    value: '''127.0.0.1'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: soapy_freq
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tcp_port
  id: variable
  parameters:
    value: '''52001'''
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.make_dict(), pmt.make_u8vector(4, ord('x')))
    period: '1000'
  states: {state: disabled}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: tx_baseband.wav
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    log: 'True'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    host: host_ip
    mtu: '10000'
    port: tcp_port
    type: TCP_SERVER
  states: {}
- name: outputFromTX
  id: blocks_file_sink
  parameters:
    file: tx_baseband.cfile
    type: complex
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: soapy_limesdr_sink_0
  id: soapy_limesdr_sink
  parameters:
    center_freq: soapy_freq
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [blocks_complex_to_real_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_message_strobe_0_0, strobe, network_socket_pdu_0_0, pdus]
- [digital_gfsk_mod_0, '0', blocks_complex_to_real_0, '0']
- [digital_gfsk_mod_0, '0', outputFromTX, '0']
- [network_socket_pdu_0_0, pdus, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', digital_gfsk_mod_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
